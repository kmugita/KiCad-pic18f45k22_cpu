# Repository kmugita/KiCad-pic18f45k22_cpu

## KiCad design PIC18F45K22_CPUBOARD_V21.kicad_pcb

Parts:
BZ1: BUZZER; Buzzer_12x6.9_Pitch5
C1, C2, C3: 10u; C_Ceramic_P5
C4, C8: 0.1u; C_0603_HandSoldering
C5, C6, C7, C9: 0.1u; C_Ceramic_P2.5
CN1: CONN_5; JST_EH_B05B-EH-A_05x2.50mm_Straight
CN2, CN3: CONN_5X2; IDC_Header_Straight_10pins
CN4: CONN_7X2; IDC_Header_Straight_14pins
F1: PTC; PTC_RXEF050
J1: USB_MiniB; USB_Mini-B_MUSB-5BF01AS
J2: con_PicKit3; Pin_Header_Angled_1x06_R
R1, R30: 4.7K; Resistor_Vertical_RM2.5mm
R2, R3: 27; R_0603_HandSoldering
RA0, RA1, RA2, RA3, RA4, RA5, RA6, RA7: LED; LED-3-S
RB0, RB1, RB2, RB3, RB4, RB5: LED; LED-3-S
RC0, RC1, RC2, RC3, RC4, RC5, RC6, RC7: LED; LED-3-S
RD0, RD1, RD2, RD3, RD4, RD5: LED; LED-3-S
RE0, RE1, RE2: LED; LED-3-S
RR1, RR2: 4.7Kx8; Resistor_Array_SIP8
RR3: RR8-SEL; Resistor_Array_SIP8-SEL
RR4: 4.7K x 4; Resistor_Array_SIP4
RR5: RR4-SEL; Resistor_Array_SIP4-SEL
SW1: SWITCH_INV; SW_2MS1-T1-B4-M2
SW2: P-03650; SW_TH_Tactile_P-036xx
U1: PIC18F45K22-I/P; DIP-40_W15.24mm_LongPads_withSocket
U2: FT231XS; SSOP-20_4.4x8.6mm_Pitch0.635mm

Connections:
+5V: C1.1, C2.1, C3.1, C5.1, C6.1, C7.1, C8.2, CN1.5, CN2.1, CN3.1, CN4.1, F1.2, J2.2 (VDD), R1.1, R30.1, RR3.1, RR4.1, RR5.1, U1.11 (VDD), U1.32 (VDD), U2.15 (VCC)
/RA0: CN1.2, RA0.2 (K), U1.2 (RA0/AN0)
/RA1: CN1.3, RA1.2 (K), U1.3 (RA1/AN1)
/RA2: CN1.4, RA2.2 (K), U1.4 (RA2/AN2/DA)
/RA3: CN4.2, RA3.2 (K), U1.5 (RA3/AN3/Vref+)
/RA4: CN4.3, RA4.2 (K), U1.6 (RA4/T0CK)
/RA5: CN4.4, RA5.2 (K), U1.7 (RA5/AN4/~SS1~)
/RA6: CN4.5, RA6.2 (K), U1.14 (RA6/CLKO/OSC2)
/RA7: CN4.6, RA7.2 (K), U1.13 (RA7/CLKI/OSC1)
/RB0: CN2.8, RB0.1 (A), U1.33 (RB0/INT0/AN12)
/RB1: CN2.9, RB1.1 (A), U1.34 (RB1/INT1/AN10)
/RB2: CN4.7, RB2.2 (K), U1.35 (RB2/INT2/AN8)
/RB3: CN4.8, RB3.2 (K), U1.36 (RB3/P2A/CCP2/AN9)
/RB4: CN4.9, RB4.2 (K), U1.37 (RB4/P2A/CCP2/AN9)
/RB5: CN4.10, RB5.2 (K), U1.38 (RB5/P3A/T1G/AN13)
/RC0: CN3.9, RC0.1 (A), U1.15 (RC0/P2B/T3CK/T1CK)
/RC1: CN3.8, RC1.1 (A), U1.16 (RC1/P2A/CCP2)
/RC2: CN3.7, RC2.1 (A), U1.17 (RC2/P1A/CCP1/T5CK/AN14)
/RC3: CN3.6, RC3.1 (A), U1.18 (RC3/SCL1/AN15)
/RC4: CN3.5, RC4.1 (A), U1.23 (RC4/SDI1/SDA1/AN16)
/RC5: CN3.4, RC5.1 (A), U1.24 (RC5/SDO1/AN17)
/RC6: CN3.3, RC6.1 (A), U1.25 (RC6/TX1/AN18)
/RC7: CN3.2, RC7.1 (A), U1.26 (RC7/RX1/AN19)
/RD0: CN4.11, RD0.2 (K), U1.19 (RD0/SCL2/AN20)
/RD1: CN2.3, RD1.1 (A), U1.20 (RD1/CCP4/SDI2/SDA2/AN21)
/RD2: CN2.5, RD2.1 (A), U1.21 (RD2/P2B/AN22)
/RD3: C9.1, CN4.13, RD3.2 (K), U1.22 (RD3/P2C/~SS2~/AN23)
/RD4: CN4.12, RD4.2 (K), SW2.3, U1.27 (RD4/P2D/SDO2/AN24)
/RD5: CN2.2, RD5.1 (A), U1.28 (RD5/P1B/AN25)
/RE0: CN2.6, RE0.1 (A), U1.8 (RE0/P3A/CCP3/AN5)
/RE1: CN2.7, RE1.1 (A), U1.9 (RE1/P3B/AN6)
/RE2: CN2.4, RE2.1 (A), U1.10 (RE2/CCP5/AN7)
/RX2: U1.30 (RD7/P1D/RX2/AN27), U2.20 (TXD)
/TX2: U1.29 (RD6/P1C/TX2/AN26), U2.4 (RXD)
GND: BZ1.2, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, CN1.1, CN2.10, CN3.10, CN4.14, J1.4 (ID), J1.5 (GND), J1.6 (FG), J2.3 (GND), RR1.1, RR2.1, RR3.10, RR5.6, SW2.1, U1.12 (VSS), U1.31 (VSS), U2.6 (GND), U2.16 (GND)
unnamed: BZ1.1, C9.2
unnamed: C4.1, U2.3 (VCCIO), U2.13 (3V3OUT), U2.14 (RESET)
unnamed: F1.1, SW1.1
unnamed: J1.1 (Vbus), SW1.2
unnamed: J1.2 (D-), R2.2
unnamed: J1.3 (D+), R3.2
unnamed: J2.1 (~MCLR~), R1.2, U1.1 (~MCLR~/RE3)
unnamed: J2.4 (ICSPDAT), U1.40 (RB7/PGD)
unnamed: J2.5 (ICSPCLK), U1.39 (RB6/PGC)
unnamed: R2.1, U2.12 (USBD-)
unnamed: R3.1, U2.11 (USBD+)
unnamed: R30.2, RD4.1 (A)
unnamed: RA0.1 (A), RR4.2
unnamed: RA1.1 (A), RR4.3
unnamed: RA2.1 (A), RR4.4
unnamed: RA3.1 (A), RR3.2
unnamed: RA4.1 (A), RR3.3
unnamed: RA5.1 (A), RR3.4
unnamed: RA6.1 (A), RR3.5
unnamed: RA7.1 (A), RR3.6
unnamed: RB0.2 (K), RR2.8
unnamed: RB1.2 (K), RR2.9
unnamed: RB2.1 (A), RR3.7
unnamed: RB3.1 (A), RR3.8
unnamed: RB4.1 (A), RR3.9
unnamed: RB5.1 (A), RR5.2
unnamed: RC0.2 (K), RR1.2
unnamed: RC1.2 (K), RR1.3
unnamed: RC2.2 (K), RR1.4
unnamed: RC3.2 (K), RR1.5
unnamed: RC4.2 (K), RR1.6
unnamed: RC5.2 (K), RR1.7
unnamed: RC6.2 (K), RR1.8
unnamed: RC7.2 (K), RR1.9
unnamed: RD0.1 (A), RR5.3
unnamed: RD1.2 (K), RR2.3
unnamed: RD2.2 (K), RR2.5
unnamed: RD3.1 (A), RR5.4
unnamed: RD5.2 (K), RR2.2
unnamed: RE0.2 (K), RR2.6
unnamed: RE1.2 (K), RR2.7
unnamed: RE2.2 (K), RR2.4

Notes on the sheet:
LED-B
LED-G
LED-R
BZ/LATCH
DCM-IN1
DCM-IN2
7SEG-L
7SEG-R
(RB0)
(RB2)
(RE1)
(RD3)
(RB1)
(RE0)
(RD2)
(RD4)
(Ver1.0)
(Ver1.0 RE2)
(Ver1.0 RD1)
(Ver1.0 RD5)
(Ver1.0 RD0)
(Ver1.0 RB4)
(Ver1.0 RB3)
(Ver1.0 RB5)
7SEG-dp
7SEG-g
7SEG-f
7SEG-e
7SEG-c/SM B+
7SEG-d/SM B-
7SEG-b/SM A-
7SEG-a/SM A+

Board: 2 copper layers, 80.0 x 84.0 mm, 61 parts (0 on the bottom side), 77 nets.

## Commit log

2019-04-26 PIC18F45K22 Version2.1
